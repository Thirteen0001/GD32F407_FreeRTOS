# Keil uVision project GD32F407.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HXTAL_VALUE=8000000,USE_RTOS
  c include: ..\User;..\Libraries\usart;..\Libraries\exti;D:\SoftWare\Keil_v5\ARM\Packs\GigaDevice\GD32F4xx_DFP\3.2.0\Device\F4XX\Include;D:\SoftWare\Keil_v5\ARM\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include;.\RTE\Device\GD32F407VE;.\RTE\RTOS;.\RTE\_Target_1;D:\SoftWare\Keil_v5\ARM\Packs\ARM\CMSIS-FreeRTOS\10.5.1\CMSIS\RTOS2\FreeRTOS\Source;D:\SoftWare\Keil_v5\ARM\Packs\ARM\CMSIS-FreeRTOS\10.5.1\Source;D:\SoftWare\Keil_v5\ARM\Packs\GigaDevice\GD32F4xx_DFP\3.2.0\Device\F4XX\Firmware\Peripherals\inc;D:\SoftWare\Keil_v5\ARM\Packs\ARM\CMSIS-FreeRTOS\10.5.1\CMSIS\RTOS2\FreeRTOS\Include;..\Libraries\timer;D:\SoftWare\Keil_v5\ARM\Packs\ARM\CMSIS-FreeRTOS\10.5.1\Source\include;D:\SoftWare\Keil_v5\ARM\Packs\ARM\CMSIS-FreeRTOS\10.5.1\Source\portable\GCC\ARM_CM4F;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c gd32f4xx_it.c systick.c
  group Hardware
    ../Hardware/leds/: bsp_leds.c
    ../Hardware/adkey/: bsp_ADKey.c
    ../Hardware/DHT11/: DHT11.c
    ../Hardware/dotmatrix/: bsp_dot_matrix.c
    ../Hardware/EC12/: bsp_EC12.c
    ../Hardware/keys/: bsp_keys.c
    ../Hardware/MatrixKeys/: MatrixKeys.c
    ../Hardware/NIXIE/: Nixie.c
    ../Hardware/PCF8563/: PCF8563.c
  group libs
    ../Libraries/usart/: Usart_config.h
    ../Libraries/exti/: Exti_config.h
    ../Libraries/adc/: ADC_config.h
    ../Libraries/i2c/: I2C_config.h
    ../Libraries/spi/: SPI_config.h
    ../Libraries/timer/: Timer_config.h
  group libs/usart
    ../Libraries/usart/: lib_usart.c lib_usart0.c
  group libs/exti
    ../Libraries/exti/: lib_exti.c
  group App
    ../App/: App.h
  group broad
    ../Hardware/: board_config.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:USART 3.0.2
